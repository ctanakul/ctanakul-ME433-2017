# Repository ctanakul/ctanakul-ME433-2017

## EAGLE design HW3/me433_2017_1_d.brd

Parts:
C1, C2, C3, C4: 0.1uF; C025-025X050
C5, C6: 10uF; B45181B
J1: USB-MB-H
LED1: Red; LED3MM
LED2: Green; LED3MM
R1, R2: 330; 0207/10
R3, R4: 10k; 0207/10
U$1: PIC32MX250F128B; DIL28-3
U$2: SLIDE
U$3: MCP1702; TO92
U$4: RESET; PB
U$5: USER; PB
U$6, U$7: CONN_08; 1X08
U$8: PICKIT3; 1X05
U$9: 8MHz; OSC

Connections:
+3V3: C1.1, C2.1, C4.1, C6.+, LED1.A, R3.2, R4.2, U$1.13 (13.VDD), U$1.23 (23.VUSB3V3), U$1.28 (28.AVDD), U$3.3 (3.VOUT), U$7.2, U$8.2 (VDD)
+5V: C3.1, U$1.15 (15.VBUS), U$2.3, U$3.2 (2.VIN), U$6.2
A0: U$1.2 (2.A0), U$7.8
A1: U$1.3 (3.A1), U$7.7
A4/LED: LED2.A, U$1.12 (12.A4/LED), U$7.3
B2: U$1.6 (6.B2), U$7.6
B3: U$1.7 (7.B3), U$7.5
B4/USER: R4.1, U$1.11 (11.B4/USER), U$5.1, U$7.4
B7: U$1.16 (16.B7), U$6.3
B8: U$1.17 (17.B8), U$6.4
B9: U$1.18 (18.B9), U$6.5
B13: U$1.24 (24.B13), U$6.6
B14: U$1.25 (25.B14), U$6.7
B15: U$1.26 (26.B15), U$6.8
D+: J1.D+, U$1.21 (21.D+/B10)
D-: J1.D-, U$1.22 (22.D-/B11)
GND: C1.2, C2.2, C3.2, C4.2, C5.-, C6.-, J1.GND, R1.1, R2.1, U$1.8 (8.VSS), U$1.19 (19.VSS), U$1.27 (27.AVSS), U$3.1 (1.GND), U$4.2, U$5.2, U$6.1, U$7.1, U$8.3 (VSS), U$9.2 (2.GND)
MCLR: R3.1, U$1.1 (1.MCLR), U$4.1, U$8.1 (MCLR)
unnamed: LED2.K (C), R2.2
unnamed: C5.+, U$1.20 (20.VCAP)
unnamed: LED1.K (C), R1.2
unnamed: U$1.9 (9.OSC1/A2), U$9.1 (1.OSC1)
unnamed: U$1.10 (10.OSC2/A3), U$9.3 (3.OSC2)
PGC: U$1.5 (5.PGC/B1), U$8.5 (PGC)
PGD: U$1.4 (4.PGD/B0), U$8.4 (PGD)
USBID: J1.ID, U$1.14 (14.USBID/B5)
VBUS: J1.VBUS, U$2.2

Board: 2 copper layers, 50.0 x 50.0 mm, 22 parts (0 on the bottom side), 27 nets.

## Commit log

2017-03-30 add pictures of vOut of voltage regulator
2017-03-30 add readme for pictures of clean and noisy signals
2017-03-30 add pictures of circuit
2017-03-30 add picts
2017-03-30 add circuit pictures in README
2017-03-30 readd picture of 1
2017-03-30 change pict1 in README.md
2017-03-30 verify that the light is on
2017-03-30 final code
2017-03-30 add circuit diagram
2017-04-04 finish Homework2
2017-04-07 finish homeoork 3
2017-04-22 finish HW4
2017-04-22 add gitignore
2017-04-22 add .gitignore
2017-04-23 finish HW5 SPI
2017-04-27 finish HW6
2017-04-27 add video of HW6
2017-04-30 finish HW7
2017-05-06 finish HW8
2017-05-14 finish hw9
2017-05-28 Finish HW10
2017-05-29 finish HW12
2017-05-29 finish hw13
2017-05-29 finish HW14
2017-06-03 Basic OpenCV inRange
2017-06-03 have color detection system with seekbars for four channels RGBA
2017-06-03 have color detection system with seekbars for min and max vals of four channels RGBA
2017-06-03 have color detection system with rangedseekbar for min and max val 3 of four channels RGBA
2017-06-03 have color detection system with rangedseekbar for min and max four channels RGBA
2017-06-04 finish HW11
2017-06-05 LittleUber can send number to Motor_Comm
2017-06-06 can show image and load value from usb in LittleUber
2017-06-06 can show image, detect green and load value from usb in LittleUber
2017-06-06 can control each wheel from android to pic
2017-06-06 can send value from app to pic dynamically
2017-06-09 finish full lap of the car
